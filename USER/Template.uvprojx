# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\MALLOC;..\USMART;..\FWLIB\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\DM9000;..\UCOSII\CONFIG;..\UCOSII\PORT;..\UCOSII\CORE;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_server_demo;..\MQTT\MQTTPacket;..\MQTT\MQTTPacket\src;..\HARDWARE\ADC;..\HARDWARE\ITEMP;..\MQTT\cjson;..\MQTT\hmac_sha1\hmac;..\MQTT\hmac_sha1\sha
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/DM9000/: dm9000.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ITEMP/: tsensor.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../MQTT/MQTTPacket/: transport.h
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group MQTT-CORE
    ../MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MQTT-API
    ../MQTT/MQTTPacket/: transport.c
  group CJSN
    ../MQTT/cjson/: cJSON.c
  group HMAC
    ../MQTT/hmac_sha1/hmac/: hmac_sha1.c
    ../MQTT/hmac_sha1/sha/: sha1.c
